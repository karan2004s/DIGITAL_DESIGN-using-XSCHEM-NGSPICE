v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {daVLSI_World/gates/AND_gate.sym} -320 120 0 0 {name=x1}
C {lab_pin.sym} -470 100 0 0 {name=p1 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -470 120 0 0 {name=p2 sig_type=std_logic lab=Ab}
C {daVLSI_World/gates/AND_gate.sym} -320 220 0 0 {name=x2}
C {lab_pin.sym} -470 220 0 0 {name=p5 sig_type=std_logic lab=A}
C {daVLSI_World/gates/inverter_vtc.sym} -670 250 0 0 {name=x3}
C {ipin.sym} -790 160 0 0 {name=p7 lab=A}
C {lab_pin.sym} -790 160 3 0 {name=p8 sig_type=std_logic lab=A}
C {lab_pin.sym} -720 160 3 0 {name=p9 sig_type=std_logic lab=Ab}
C {lab_pin.sym} -770 130 0 0 {name=p10 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -470 200 0 0 {name=p4 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -582 140 2 0 {name=p12 sig_type=std_logic lab=EN}
C {lab_pin.sym} -470 240 0 0 {name=p13 sig_type=std_logic lab=EN}
C {lab_pin.sym} -470 140 0 0 {name=p3 sig_type=std_logic lab=EN}
C {opin.sym} -344 120 0 0 {name=p6 lab=D0}
C {opin.sym} -344 220 0 0 {name=p11 lab=D1}
C {ipin.sym} -770 130 1 0 {name=p14 lab=vdd}
C {ipin.sym} -582 140 0 0 {name=p15 lab=EN}
